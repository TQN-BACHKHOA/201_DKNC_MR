# Keil uVision project PROJ.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PROJ
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx,HSE_VALUE=8000000
  c include: ..\MDK-ARM;..\..\project;..\STM32F4xx_StdPeriph_Driver\inc;..\CMSIS\Include;..\CMSIS\Device\ST\STM32F4xx\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../: main.c stm32f4xx_it.c
    ./: user_STR_Controller.c user_STR_Controller.h
  group CMSIS
    ../: system_stm32f4xx.c
  group MDK-ARM
    ../CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group DRIVER
    ../STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_tim.c stm32f4xx_gpio.c misc.c stm32f4xx_rcc.c stm32f4xx_exti.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_dma.c
